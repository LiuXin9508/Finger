# Keil uVision project Figner_led.uvproj, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Figner_led +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051
  c misc: --C99
  c include: ..\CMSIS\Include;..\LIB\Include;..\LIB\STM32F0xx_StdPeriph_Driver\inc;..\USER\inc;..\USER\board\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: system_stm32f0xx.c
  group LIB
    ../LIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ../USER/: main.c stm32f0xx_it.c
  group START
    ../CMSIS/: startup_stm32f051.s
  group Head
    ../USER/inc/: main.h stm32f0xx_conf.h stm32f0xx_it.h
  group BoardService
    ../USER/board/src/: GPIO.c LCD.c uart.c finger.c PC.c flash.c
    ../USER/board/inc/: GPIO.h LCD.h uart.h finger.h PC.h flash.h
